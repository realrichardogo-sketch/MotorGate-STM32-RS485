# Keil uVision project PPP03_motor_hal.uvprojx, settings and files
target PPP03_motor_hal (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: PPP03_motor_hal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -DNDEBUG
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./common;./application;./interface;./freeModbus/modbus;./freeModbus/modbus/ascii;./freeModbus/modbus/functions;./freeModbus/modbus/include;./freeModbus/modbus/rtu;./freeModbus/modbus/tcp;./freeModbus/port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group common
    ./common/: Com_debug.c Com_PID.c
  group interface
    ./interface/: Int_OLED.c Int_M24C02.c Int_motor.c
  group application
    ./application/: App_display.c App_key.c App_run.c
  group freeModbus/modbus
    ./freeModbus/modbus/: mb.c
    ./freeModbus/modbus/ascii/: mbascii.c
    ./freeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./freeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./freeModbus/modbus/tcp/: mbtcp.c
  group freeModbus/port
    ./freeModbus/port/: port.h portevent.c portserial.c porttimer.c port.c
software components: CMSIS:CORE 4.3.0
